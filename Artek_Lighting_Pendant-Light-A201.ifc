Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-09-28T20:05:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 28 20:05:48 2022 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\{C42CCC5D-4CDC-4089-8099-3D27A3D7E1F0}\ifc * Database version: 5507 * Database creation date: Wed Sep 28 20:05:47 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 28 20:05:47 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 28 20:05:47 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowTerminal: Pendant Light A201, Artek_Lighting_Pendant-Light-A201:Pendant Light A201:13162
In: Level 1
Type - Material: White Steel, Brass, Rubber, Black
Type - Constraints - DefaultElevation: 0 mm; NominalVoltageCalc: 0 V
Type - Dimensions - Light Source Symbol Size: 609.6 mm; NominalDiameter: 290 mm; NominalLength: 290 mm; NominalRadius: 145 mm; NominalWidth: 290 mm
Type - General - BIMObjectName: Artek_Lighting_Pendant-Light-A201; ManufacturerName: Artek; ManufacturerURL: https://www.artek.fi/; NBSDescription: General purpose luminaires; NBSReference: 90-60-50/405; ProductInformation: Pendant Light A201 was designed by Alvar Aalto in 1952 for the library of Säynätsalo Town Hall in central Finland. Composed of formed sheet steel, Pendant Light A201 possesses a sculptural presence; its beauty can be appreciated whether switched on or off. The light exiting the lower and upper part of the shade creates a beautiful halo, typical to Aalto who sought to make artificial light as indirect and soft as possible. The A201 is available in standard white with brass details.; Revision: n/a; Uniclass2: Pr_70_70_49_86; Uniclass2015Description: Pendant luminaires; Uniclass2015Reference: Pr_70_70_48_62; Version: 1; VersionDate: 27/09/2022
Type - Identity Data - Collection: Pendant Lights; Description: Pendant Light A201 was designed by Alvar Aalto in 1952 for the library of Säynätsalo Town Hall in central Finland. Composed of formed sheet steel, Pendant Light A201 possesses a sculptural presence; its beauty can be appreciated whether switched on or off. The light exiting the lower and upper part of the shade creates a beautiful halo, typical to Aalto who sought to make artificial light as indirect and soft as possible. The A201 is available in standard white with brass details.; Designer: Alvar Aalto; Manufacturer: Artek; Model: Pendant Light A201; OmniClass Number: 23.80.70.00; OmniClass Title: Lighting; Type Name: Pendant Light A201; URL: https://www.artek.fi/en/products/pendant-light-a201
Type - Materials and Finishes - LightFixtureMainMaterial: White Steel; LightFixtureSecondaryMaterial: White Steel; LightFixtureTertiaryMaterial: Brass
Type - Other - Category: Lighting Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Artek; CodePerformance: n/a; Color: White; Constituents: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: Artek_Lighting_Pendant-Light-A201; Features: Shade powder coated, ring brass-plated; Finish: n/a; Grade: n/a; Material: Steel, powder coated; ModelNumber: n/a; ModelReference: n/a; Name: Pendant-Light-A201; ReplacementCost: n/a; Shape: Sculptured; Size: 225x225x215 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Photometrics - Color Filter: 16777215; Dimming Lamp Color Temperature Shift: <None>; Efficacy: 148.542 s3*lm/kg/m2; Illuminance: 11.8206 lx; Initial Color: 0; Initial Color Temperature: 3000 K; Initial Intensity: 0; Light Loss Factor: 0; Light Source Definition (family): Point+Spherical; Luminous Flux: 1380 lm; Luminous Intensity: 109.817 cd; Total Light Loss Factor: 1; Wattage: 9.2903 W
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Construction - CableLength: 700 mm; CableLengthControl: 700 mm
Dimensions - Area: 1.27591 m2; NominalHeight: 1033 mm; Volume: 0.205524 m3
Electrical - Circuiting - Electrical Data: 0 V/1-0 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 5
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Artek_Lighting_Pendant-Light-A201: Pendant Light A201; Family and Type: Artek_Lighting_Pendant-Light-A201: Pendant Light A201; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Artek_Lighting_Pendant-Light-A201: Pendant Light A201; Type Id: Artek_Lighting_Pendant-Light-A201: Pendant Light A201; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
